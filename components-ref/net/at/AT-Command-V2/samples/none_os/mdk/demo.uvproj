# Keil uVision project demo.uvproj, settings and files
target codebrick (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: codebrick +hex
  AfterMake: fromelf --bin !L --output demo.bin
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER
  c misc: --c99 --gnu
  c include: ..\driver\inc;..\framework;..\lib\CMSIS\Include;..\lib\CMSIS\STM32F4xx\Include;..\user;..\user\module;..\lib\STM32F4xx_StdPeriph_Driver\inc;..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(init.item.*)
  group at_chat
    ../../../src/: at_chat.c
    ../user/: at_port.c
  group startup
    ../lib/CMSIS/STM32F4xx/Source/arm/: startup_stm32f4xx.s
  group driver
    ../driver/src/: mcu_flash.c tty.c wifi_uart.c
  group framework
    ../framework/: blink.c key.c module.c ringbuffer.c cli.c
  group CMSIS
    ../lib/CMSIS/STM32F4xx/Source/: system_stm32f4xx.c
  group StdPeriph_Driver
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group user
    ../user/: led.c main.c platform.c public.c stm32f4xx_it.c
  group user/task
    ../user/task/: cli_task.c task_key.c wifi_task.c
  group user/cmd
    ../user/cmd/: cmd_devinfo.c
